options:
  parameters:
    author: yasht
    description: LPI-CGAN Receiver (raw capture + inline normalized decode) + USRP
    generate_options: qt_gui
    id: rx_lpi_cgan
    output_language: python
    title: LPI-CGAN Receiver
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    comment: 2.484 GHz ISM Channel 14
    value: '2484000000'
  states: {}
- name: frame_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 245.76 kS/s covert streaming
    value: '245760'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Inline-decoded symbols (pre-alignment - use rx_raw.fc32 + ota_verify.py for the real BER)
    file: C:\\Users\\gspra\\OneDrive\\Desktop\\LPI_CGAN\\recovered_symbols.fc32
    type: complex
  states: {}
- name: blocks_file_sink_raw
  id: blocks_file_sink
  parameters:
    comment: RAW baseband capture - feed ota_verify.py for offline alignment + BER + KS field test
    file: C:\\Users\\gspra\\OneDrive\\Desktop\\LPI_CGAN\\rx_raw.fc32
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: Accumulate 512 covert samples into one vector
    num_items: '512'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '256'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import os
      import sys
      import numpy as np

      # Ensure PyTorch and project modules are accessible across all conda environments
      for _extra_path in [
          r"C:\Users\gspra\radioconda\Lib\site-packages",
          r"C:\Users\gspra\OneDrive\Desktop\LPI_CGAN",
          os.path.abspath(os.path.join(os.path.dirname(__file__), "..")) if "__file__" in globals() else "",
      ]:
          if _extra_path and os.path.exists(_extra_path) and _extra_path not in sys.path:
              sys.path.insert(0, _extra_path)

      from gnuradio import gr


      class cgan_decoder_block(gr.sync_block):
          """CGAN Covert LPI Signal Decoder.
          Accepts vectors of 512 complex baseband samples, performs standard normalization,
          and infers 256 decoded BPSK symbols (-1.0 / +1.0) using the trained neural receiver.
          """

          def __init__(self, model_path="decoder_lpi.pt"):
              gr.sync_block.__init__(
                  self,
                  name="CGAN_LPI_Decoder",
                  in_sig=[(np.complex64, 512)],
                  out_sig=[(np.complex64, 256)],
              )
              self.model_path = str(model_path)
              self.torch = None
              self.model = None
              self.device = "cpu"
              self.gpu_input = None
              self._load_model()

          def _load_model(self):
              try:
                  import torch
                  self.torch = torch
                  self.device = "cpu"
                  raw_path = self.model_path.strip("'\"")
                  resolved_path = None
                  candidates = [
                      raw_path,
                      os.path.join(r"C:\Users\gspra\OneDrive\Desktop\LPI_CGAN", raw_path),
                      os.path.join(r"C:\Users\gspra\OneDrive\Desktop\LPI_CGAN", "decoder_lpi.pt"),
                      os.path.join(os.path.dirname(__file__), "decoder_lpi.pt") if "__file__" in globals() else "",
                      os.path.join(os.path.dirname(__file__), "..", "decoder_lpi.pt") if "__file__" in globals() else "",
                  ]
                  for cand in candidates:
                      if cand and os.path.exists(cand):
                          resolved_path = os.path.abspath(cand)
                          break

                  if resolved_path and os.path.exists(resolved_path):
                      self.model = torch.jit.load(resolved_path, map_location=self.device)
                      self.model.eval()
                      self.gpu_input = torch.zeros(1, 2, 512, dtype=torch.float32, device=self.device)
                      print(f"[CGAN Dec] Successfully loaded TorchScript model from {resolved_path}")
                  else:
                      print(f"[CGAN Dec] Note: Model '{raw_path}' will be loaded when flowgraph starts.")
              except Exception as e:
                  print(f"[CGAN Dec] Note during inspection: {e}")

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              num_frames = len(in0)
              if num_frames == 0:
                  return 0

              if self.model is None:
                  self._load_model()

              if self.model is None or self.torch is None:
                  # Fallback zero/pass-through if model weights unavailable
                  for i in range(num_frames):
                      out[i] = np.sign(in0[i][:256].real).astype(np.complex64)
                  return num_frames

              for i in range(num_frames):
                  frame = in0[i]
                  v = np.concatenate([frame.real, frame.imag]).astype(np.float32)
                  v[:512] -= v[:512].mean()
                  v[512:] -= v[512:].mean()
                  v = v / np.sqrt((v * v).mean() + 1e-8)
                  self.gpu_input[0, 0, :] = self.torch.from_numpy(v[:512])
                  self.gpu_input[0, 1, :] = self.torch.from_numpy(v[512:])
                  with self.torch.no_grad():
                      b_hat = self.model(self.gpu_input).cpu().numpy()[0]
                  symbols = np.where(b_hat > 0.5, 1.0, -1.0).astype(np.complex64)
                  out[i] = symbols

              return num_frames
    comment: CGAN Decoder (with per-frame normalization)
    model_path: '''decoder_lpi.pt'''
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: RX I
    label2: RX Q
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    gain0: rx_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_raw, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
